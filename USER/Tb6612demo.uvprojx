# Keil uVision project Tb6612demo.uvprojx, settings and files
target Tb6612demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWER\MOTO;..\HAREWER\PWM;..\HAREWER\GPIO;..\HAREWER\ADC;..\HAREWER\ENCODER;..\HAREWER\TIMER;..\HAREWER\OLED;..\HAREWER\DHT22;..\HAREWER\OLED;..\HAREWER\ESP8266;..\HAREWER\Serial;..\HAREWER\CONTROL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWER
    ../HAREWER/MOTO/: moto.c
    ../HAREWER/PWM/: pwm.c
    ../HAREWER/GPIO/: gpio.c
    ../HAREWER/ENCODER/: encoder.c
    ../HAREWER/ADC/: adc.c
    ../HAREWER/TIMER/: timer.c
    ../HAREWER/: OLED.c OLED.h OLED_Font.h
    ../HAREWER/DHT22/: DHT22.c DHT22.h
    ../HAREWER/ESP8266/: ESP8266.c ESP8266.h
    ../HAREWER/Serial/: Serial.c Serial.h
    ../HAREWER/CONTROL/: Control.c Control.h
